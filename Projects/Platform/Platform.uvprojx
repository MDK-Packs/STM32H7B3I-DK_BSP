# Keil uVision project Platform.uvprojx, settings and files
target STM32H7B3I-DK (6210000::V6.21::ARMCLANG)
  device: STM32H7B3LIHxQ STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00100000) IROM(0x08000000,0x00100000) IROM2(0x08100000,0x00100000) XRAM(0x30000000,0x00020000) XRAM2(0x38000000,0x00008000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: image
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DATA_IN_D2_SRAM
  c include: .\Board_IO
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x8100000 size 0x100000
  memory RVCT6: RAM 0x30000000 size 0x20000
  memory RVCT7: RAM 0x38000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x100000
  scatter file: .\stm32h7b3.sct
  link misc: --any_placement=first_fit
  group App
    ./: Platform.c
  group Board IO
    ./Board_IO/: retarget_stdio.c
  group :STM32CubeMX:Common Sources
    ./STM32CubeMX/STCubeGenerated/Src/: main.c stm32h7xx_it.c
    ./STM32CubeMX/STCubeGenerated/Inc/: stm32h7xx_it.h
  group STM32CubeMX
    ./STM32CubeMX/STCubeGenerated/: STCubeGenerated.ioc
  group Documentation
    ./: README.md
software components: CMSIS-Compiler:CORE 1.0.0, CMSIS-Compiler:STDERR:Custom 1.0.0, CMSIS-Compiler:STDIN:Custom 1.0.0, CMSIS-Compiler:STDOUT:Custom 1.0.0, CMSIS-View:Event Recorder 1.5.3, CMSIS:CORE 6.0.0, CMSIS:OS Tick:SysTick 1.0.5, CMSIS:RTOS2:Keil RTX5 5.8.0, Board Support:Drivers:BUS 2.3.0, Board Support:Drivers:Basic I/O 2.3.0, CMSIS Driver:MCI 1.8.0, CMSIS Driver:SPI 1.6.0, CMSIS Driver:USART 2.3.0, CMSIS Driver:VIO:Board 2.0.0, CMSIS Driver:WiFi:ISM43362 1.15.0, Device:STM32Cube Framework:STM32CubeMX 2.0.0, Device:STM32Cube HAL:Common 1.11.0, Device:STM32Cube HAL:Cortex 1.11.0, Device:STM32Cube HAL:DMA 1.11.0, Device:STM32Cube HAL:EXTI 1.11.0, Device:STM32Cube HAL:GPIO 1.11.0, Device:STM32Cube HAL:I2C 1.11.0, Device:STM32Cube HAL:I2S 1.11.0, Device:STM32Cube HAL:IRDA 1.11.0, Device:STM32Cube HAL:MMC 1.11.0, Device:STM32Cube HAL:PWR 1.11.0, Device:STM32Cube HAL:RCC 1.11.0, Device:STM32Cube HAL:RTC 1.11.0, Device:STM32Cube HAL:SD 1.11.0, Device:STM32Cube HAL:SPI 1.11.0, Device:STM32Cube HAL:Smartcard 1.11.0, Device:STM32Cube HAL:UART 1.11.0, Device:STM32Cube HAL:USART 1.11.0, Device:Startup 1.11.0
